# Keil uVision project Nucleo411.uvproj, settings and files
target Nucleo411 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(100000000) ELITTLE
  output: Nucleo411 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CMSIS;..\STM_Lib\inc;..\USER;..\FATFS;..\BoardHardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group StartUp
    ../StartUp/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: system_stm32f10x.c
  group STM_Lib
    ../STM_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c core_cm3.c
  group USER
    ../USER/: main.c usart.c delay.c stm32f10x_it.c
  group BoardHardware
    ../BoardHardware/: SPI1.c
  group FATFS
    ../FATFS/: diskio.c ff.c MMC_SD.c
